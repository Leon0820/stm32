# Keil uVision project Project.uvproj, settings and files
target STM32100E-EVAL (ARM-ADS)
  device: STM32F100ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD_VL, USE_STM32100E_EVAL
  c include: ..\inc\;..\..\..\Libraries\Embedded_GUI_Library\inc;..\..\..\Libraries\Embedded_GUI_HAL\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM32100E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../src/: system_stm32f10x.c hw_config.c main.c pictures.c stm32f10x_it.c stm32f2xx_it.c stm32l1xx_it.c system_stm32f2xx.c system_stm32l1xx.c uiappuser.c uiframework.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_sdio.c
  group CMSIS
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c stm3210c_eval_ioe.c
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval_lcd.c stm32100e_eval_ioe.c
    ../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c stm322xg_eval_ioe.c
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval_lcd.c
  group MDK-ARM
    ./: startup_stm32f10x_md_vl.s startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_md.s startup_stm32f10x_xl.s startup_stm32l1xx_md.s startup_stm32f2xx.s
  group GUI_HAL
    ../../../Libraries/Embedded_GUI_HAL/src/: LcdHal.c touchscreen.c TscHal.c JoyHal.c
  group GUI_Library
    ../../../Libraries/Embedded_GUI_Library/src/: images.c cursor.c gl_fonts.c graphicObject.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_syscfg.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_fsmc.c stm32f2xx_usart.c stm32f2xx_sdio.c stm32f2xx_spi.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_usart.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_i2c.c
target STM32100B-EVAL (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD_VL, USE_STM32100B_EVAL
  c include: ..\inc\;..\..\..\Libraries\Embedded_GUI_Library\inc;..\..\..\Libraries\Embedded_GUI_HAL\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM32100B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\inc\;..\..\..\Libraries\Embedded_GUI_Library\inc;..\..\..\Libraries\Embedded_GUI_HAL\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\inc\;..\..\..\Libraries\Embedded_GUI_Library\inc;..\..\..\Libraries\Embedded_GUI_HAL\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\inc\;..\..\..\Libraries\Embedded_GUI_Library\inc;..\..\..\Libraries\Embedded_GUI_HAL\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM3210E-EVAL_XL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL_XL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
target STM322xG_EVAL (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F2XX, USE_STM322xG_EVAL
  c include: ..\inc\;..\..\..\Libraries\Embedded_GUI_Library\inc;..\..\..\Libraries\Embedded_GUI_HAL\inc;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM32L152_EVAL (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c include: ..\inc\;..\..\..\Libraries\Embedded_GUI_Library\inc;..\..\..\Libraries\Embedded_GUI_HAL\inc;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
